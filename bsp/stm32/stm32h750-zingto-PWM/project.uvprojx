# Keil uVision project project.uvprojx, settings and files
target rtthread (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H750xx, USE_HAL_DRIVER
  c include: .;..\..\..\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\common;..\..\..\components\utilities\ulog;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\STM32H7xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_wdt.c drv_common.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_wwdg.c
